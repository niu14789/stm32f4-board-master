# Keil uVision project Om.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: output +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,USE_EMBEDDED_PHY
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User\bsp_stm32f4xx\inc;..\..\User\bsp_stm32f4xx;..\..\User;..\..\Libraries\STM32_USB_Device_Library\Class\msc\inc;..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\User\usb_mass_storage;..\..\User\iapss;..\..\User\iapss\fatfs;..\..\Hardware\io;..\..\Hardware\led;..\..\Hardware\key;..\..\Hardware\usart;..\..\Hardware\exit;..\..\Hardware\pwm;..\..\Hardware\adc;..\..\Hardware\rtc;..\..\fs;..\..\driver\lcd;..\..\driver\lcd\ra8875;..\..\driver\sd\sd_driver;..\..\driver\sd\fatfs;..\..\gui\widget\button;..\..\gui\gui;..\..\driver\led;..\..\gui\server;..\..\driver\sram;..\..\gui\widget\window;..\..\driver\lcd\ili93xx;..\..\gui\gui_config;..\..\driver\touch;..\..\gui\pic\bmp;..\..\driver\i2c;..\..\driver\e2p
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __FS_*
  group User
    ../../User/: main.c
    ../../User/bsp_stm32f4xx/: stm32f4xx_it.c
    ../../Hardware/usart/: stm32_usart.c
    ../../Hardware/rtc/: rtc.c
  group mdk_arm
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group fwlib
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_rtc.c stm32f4xx_pwr.c
  group cmsis
    ../../User/bsp_stm32f4xx/: system_stm32f4xx.c
  group fs
    ../../fs/: f_open.c f_close.c f_inode.c f_write.c f_read.c f_lseek.c
  group lcd1
    ../../driver/lcd/ra8875/: lcd_ap.c lcd_hw.c lcd_interface.c lcd_gui.c
  group touch
    ../../driver/lcd/ra8875/: touch_ap.c
  group sd
    ../../driver/sd/sd_driver/: stm32_sdio.c sd_interface.c sd_gui.c
    ../../driver/sd/fatfs/: diskio.c ff.c
  group gui
    ../../gui/widget/slider/: slider.c
    ../../gui/gui/: gui.c
    ../../gui/widget/button/: button.c
    ../../gui/widget/window/: window.c
    ../../gui/gui_config/: gui_config.c
    ../../gui/pic/bmp/: bmp.c
  group led
    ../../driver/led/: led.c led_gui.c
  group queue
    ../../queue/: queue.c queuel0.c
  group key
    ../../driver/key/: key.c key_gui.c
  group server
    ../../gui/server/: server.c
  group sram
    ../../driver/sram/: sram.c
  group lcd2
    ../../driver/lcd/ili93xx/: lcd.c lcd_fs.c
  group touch2
    ../../driver/touch/: touch.c
  group i2c
    ../../driver/i2c/: i2c.c
  group e2p
    ../../driver/e2p/: e2p.c
target CpuRAM (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: output +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,VECT_TAB_SRAM,USE_USB_OTG_FS,USE_EMBEDDED_PHY
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User\bsp_stm32f4xx\inc;..\..\User\bsp_stm32f4xx;..\..\User;..\..\Libraries\STM32_USB_Device_Library\Class\msc\inc;..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\User\usb_mass_storage
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
